# Keil uVision project ZQ_STM32F107_MINI_V3_0.uvprojx, settings and files
target ZQ_STM32F107_MINI_V3_0 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: ZQ_STM32F107_MINI_V3_0
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F107xC
  c misc: --C99
  c include: ../Inc;  ../Middlewares/Third_Party/LwIP/system;  ../Middlewares/Third_Party/LwIP/src/include;  ../Middlewares/Third_Party/LwIP/src/include/ipv4;  ../Drivers/STM32F1xx_HAL_Driver/Inc;  ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;  ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;  ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;  ../Middlewares/ST/STM32_USB_Device_Library/Class/AUDIO/Inc;  ../Middlewares/Third_Party/FatFs/src;  ../Middlewares/Third_Party/FreeRTOS/Source/include;  ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;  ../Middlewares/Third_Party/LwIP/system/arch;  ../Middlewares/Third_Party/LwIP/src/include/ipv4/lwip;  ../Middlewares/Third_Party/LwIP/src/include/lwip;  ../Middlewares/Third_Party/LwIP/src/include/netif;  ../Middlewares/Third_Party/LwIP/src/include/posix;  ../Middlewares/Third_Party/LwIP/src/include/posix/sys;  ../Middlewares/Third_Party/LwIP/src/netif/ppp;  ../Drivers/CMSIS/Include;  ../Drivers/CMSIS/Device/ST/STM32F1xx/Include
  asm include: ..\Inc
  library: MicroLIB
  link misc: --diag_suppress=L6329
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/core/: raw.c sys.c tcp.c init.c dhcp.c tcp_in.c mem.c stats.c lwip_timers.c dns.c pbuf.c def.c memp.c tcp_out.c netif.c udp.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: vj.c ppp_oe.c chpms.c magic.c chap.c auth.c fsm.c randm.c ipcp.c lcp.c md5.c ppp.c pap.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c icmp.c ip_frag.c inet.c ip.c ip_addr.c igmp.c inet_chksum.c
    ../Middlewares/Third_Party/LwIP/src/core/snmp/: msg_out.c mib2.c mib_structs.c msg_in.c asn1_dec.c asn1_enc.c
    ../Middlewares/Third_Party/LwIP/src/netif/: slipif.c etharp.c
    ../Middlewares/Third_Party/LwIP/src/api/: netdb.c api_msg.c netbuf.c sockets.c api_lib.c tcpip.c netifapi.c err.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
    ../Middlewares/Third_Party/FatFs/src/: ff.c ff_gen_drv.c diskio.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_ctlreq.c usbd_core.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/AUDIO/Src/: usbd_audio.c
  group Application/MDK-ARM
    ./: startup_stm32f107xc.s
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_i2c.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_usart.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_cortex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_eth.c stm32f1xx_hal_can.c stm32f1xx_hal_crc.c stm32f1xx_hal.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pcd.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_wwdg.c stm32f1xx_hal_adc.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rcc.c stm32f1xx_hal_flash.c stm32f1xx_ll_usb.c stm32f1xx_hal_dma.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: event_groups.c tasks.c list.c queue.c timers.c croutine.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Application/User
    ../Src/: usbd_audio_if.c main.c freertos.c usbd_desc.c usb_device.c lwip.c stm32f1xx_hal_msp.c user_diskio.c fatfs.c stm32f1xx_it.c ethernetif.c usbd_conf.c stm32f1xx_hal_timebase_TIM.c
software components: CMSIS:CORE 4.1.0
